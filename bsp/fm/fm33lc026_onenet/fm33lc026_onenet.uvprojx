# Keil uVision project fm33lc026_onenet.uvprojx, settings and files
target fm33lc026_onenet (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: FM33LC02X FMSH
  pack: Keil.FM33LC0XX_DFP.1.0.4
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33LC0xx_OneNet +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERT,_DLIB_FILE_DESCRIPTOR
  c include: ..\libraries\FM33LC0xx_LL\CMSIS\Device\FM\FM33xx\Include;..\libraries\FM33LC0xx_LL\FM33LC0xx_LL_Driver\Inc;..\libraries\FM33LC0xx_LL\CMSIS\Inculde;..\libraries\HAL_driver;.\applications\include;..\fm33lc026_onenet;.\board;..\..\..\include;..\..\..\include\icp;..\..\..\include\ocp;..\..\..\components\at;..\..\..\include\ocp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application
    ./applications/: main.c mf_config.c sleep.c
  group Board
    ./board/: board.h board.c
    ../libraries/FM33LC0xx_LL/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
    ../libraries/FM33LC0xx_LL/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
  group Drivers
    ../libraries/HAL_driver/: drv_common.c drv_gpio.c drv_lptim.c drv_uart.c drv_wdt.c drv_adc.c
  group DeviceDrivers
    ../../../libmod/icp/: pin.c serial.c watchdog.c adc.c
  group Bare_sys
    ../../../src/: device.c timer.c kservice.c object.c
  group FM33LC0xx_LL_Driver
    ../libraries/FM33LC0xx_LL/FM33LC0xx_LL_Driver/Src/: fm33lc0xx_ll_adc.c fm33lc0xx_ll_aes.c fm33lc0xx_ll_atim.c fm33lc0xx_ll_bstim.c fm33lc0xx_ll_comp.c fm33lc0xx_ll_crc.c fm33lc0xx_ll_dma.c fm33lc0xx_ll_flash.c fm33lc0xx_ll_gpio.c fm33lc0xx_ll_gptim.c fm33lc0xx_ll_hdiv.c fm33lc0xx_ll_i2c.c fm33lc0xx_ll_iwdt.c fm33lc0xx_ll_lcd.c fm33lc0xx_ll_lptim.c fm33lc0xx_ll_lpuart.c fm33lc0xx_ll_opa.c fm33lc0xx_ll_pmu.c fm33lc0xx_ll_rcc.c fm33lc0xx_ll_rng.c fm33lc0xx_ll_rtc.c fm33lc0xx_ll_spi.c fm33lc0xx_ll_svd.c fm33lc0xx_ll_u7816.c fm33lc0xx_ll_uart.c fm33lc0xx_ll_wwdt.c
  group Deom
    ../../../demo/: demo_gpio.c demo_serial.c demo_bc35.c
  group At
    ../../../components/at/: at_base.c bc35.c
